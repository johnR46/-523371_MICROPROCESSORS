		ORG 	8000H
C7SEG		EQU	0E060H

START:		MOV	R0,#0
MAIN:		MOV	A,R0
		INC	R0
		ACALL	TAB01
		MOV	DPTR,#C7SEG
		MOVX	@DPTR,A
		ACALL 	DELAY_430M
		CJNE	R0,#10H,MAIN
		SJMP	START
		
TAB01:		MOV	DPTR,#DATA1
		MOVC	A,@A+DPTR
		RET
			
DELAY_430M: 	CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY10MS
		CALL	DELAY10MS
		CALL	DELAY10MS			
		RET
		
DELAY100MS:	MOV	R6,#200
DLY100MS:	CALL	DELAY500U
		DJNZ	R6,DLY100MS	
		RET
		
DELAY10MS:	MOV	R7,#20
DLY10MS:	CALL	DELAY50U
		DJNZ	R7,DLY10MS	
		RET
		
DELAY500U:	MOV	R5,#230
		DJNZ	R5,$
		RET
		
DELAY50U:	MOV	R4,#23
		DJNZ	R4,$
		RET

	
DATA1:	DB	3FH,06H,5BH,4FH
	DB	66H,6DH,7DH,07H
	DB	7FH,6FH,77H,7CH
	DB	39H,5EH,79H,71H



	END
	